# Keil uVision project keypad_sin.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C5131A Atmel
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(32000000) MODP2
  output: keypad_sin +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: keypad_sin.c
